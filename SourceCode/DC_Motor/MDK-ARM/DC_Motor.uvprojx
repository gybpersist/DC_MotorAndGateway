# Keil uVision project DC_Motor.uvprojx, settings and files
target DC_Motor (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: DC_Motor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: -DNDEBUG
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Development/App;../Development/Com;../Development/Dri;../Development/Int;../Development/Int/OLED;../Development/Mid;../Development/Mid/FreeRTOS;../Development/Mid/FreeRTOS/include;../Development/Mid/FreeRTOS/portable;../Development/Mid/FreeRTOS/portable/MemMang;../Development/Mid/FreeRTOS/portable/RVDS/ARM_CM3;../Development/Mid/FreeRTOS/source;../Development/Mid/FreeModbus/modbus;../Development/Mid/FreeModbus/modbus/ascii;../Development/Mid/FreeModbus/modbus/functions;../Development/Mid/FreeModbus/modbus/include;../Development/Mid/FreeModbus/modbus/rtu;../Development/Mid/FreeModbus/port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Development/App
    ../Development/App/: App_Task.c App_Task.h App_Display.c App_Display.h App_Key.c App_Key.h App_EEPROM.c App_EEPROM.h App_Motor.c App_Motor.h App_Modbus.c App_Modbus.h
  group Development/Com
    ../Development/Com/: Com_Debug.c Com_Debug.h Com_Util.c Com_Util.h Com_Define.c Com_Define.h
  group Development/Int
    ../Development/Int/: Int_M24C02.c Int_M24C02.h Int_Key.c Int_Key.h Int_Motor.c Int_Motor.h
  group Development/Int/OLED
    ../Development/Int/OLED/: Int_font.h Int_OLED.c Int_OLED.h
  group Development/Mid/FreeRTOS
    ../Development/Mid/FreeRTOS/: FreeRTOSConfig.h
  group Development/Mid/FreeRTOS/include
    ../Development/Mid/FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group Development/Mid/FreeRTOS/portable/MemMang
    ../Development/Mid/FreeRTOS/portable/MemMang/: heap_4.c
  group Development/Mid/FreeRTOS/portable/RVDS/ARM_CM3
    ../Development/Mid/FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
  group Development/Mid/FreeRTOS/source
    ../Development/Mid/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Development/Mid/FreeModbus/modbus
    ../Development/Mid/FreeModbus/modbus/: mb.c
    ../Development/Mid/FreeModbus/modbus/ascii/: mbascii.c mbascii.h
    ../Development/Mid/FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../Development/Mid/FreeModbus/modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
    ../Development/Mid/FreeModbus/modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
  group Development/Mid/FreeModbus/port
    ../Development/Mid/FreeModbus/port/: port.c port.h portevent.c portserial.c porttimer.c
software components: CMSIS:CORE 4.3.0
